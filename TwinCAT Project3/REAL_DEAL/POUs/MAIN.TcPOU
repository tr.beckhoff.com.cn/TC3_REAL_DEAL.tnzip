PROGRAM MAIN
VAR
	USIN1: LREAL;
	IN_LREAL:LREAL;
	IN_P:INT;
	
END_VAR

USIN1:=FC_REAL_DEAL(IN_LREAL,IN_P);

END_PROGRAM
